# IAR project gibmal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx
  ICCARM.CCIncludePath2: user_code; ..\..\libraries\util; ..\..\libraries\stm32f4_gadget; ..\..\hardware_config; ..\..\st_stdperiph_lib\CMSIS\Include; ..\..\st_stdperiph_lib\CMSIS\Device\ST\STM32F4xx\Include; ..\..\st_stdperiph_lib\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: gibmal.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: ..\..\hardware_config\stm32f401xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  group hardware_config
    ../../hardware_config/: stm32f4xx_conf.h system_stm32f4xx_gimbal_board.c
  group libraries/stm32f4_gadgets
    ../../libraries/stm32f4_gadget/: digital_out.cpp pwm_measurement_timer.cpp pwm_out_advanced_timer.cpp
  group libraries/util
    ../../libraries/util/: trigtables.c
  group st_stdperiph_lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar
    ../../st_stdperiph_lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s
  group st_stdperiph_lib/STM32F4xx_StdPeriph_Driver/src
    ../../st_stdperiph_lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user_code
    user_code/: CircularBuffer.c dma_rx.cpp dma_tx.cpp encoder.cpp error.cpp jsmn.c main.cpp message_parser.cpp motor_commutation_calibration.cpp nerm_lab_constants.cpp stm32f4xx_it.c usart.cpp
